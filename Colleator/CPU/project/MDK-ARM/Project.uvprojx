# Keil uVision project Project.uvprojx, settings and files
target N32G4FR (6130001::V6.13.1::.\ARMCLANG)
  device: N32G4FRKEQ7 Nationstech
  pack: Nationstech.N32G4FR_DFP.1.0.4
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: collector +hex
  AfterMake: fromelf --bin --output=.\bin\collector.bin .\Objects\collector.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: N32G4FR, USE_STDPERIPH_DRIVER, MINIZ_NO_STDIO, MINIZ_NO_TIME
  c include: ..\sys;..\..\Libraries\CMSIS\core;..\..\Libraries\CMSIS\device;..\..\Libraries\n32g4fr_std_periph_driver\inc;..\driver;..\dev;..\app;..\proto;..\algo
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  scatter file: .\collector.sct
  group STARTUP
    ../../Libraries/CMSIS/device/startup/: startup_n32g4fr.s
  group CMSIS
    ../../Libraries/CMSIS/device/: system_n32g4fr.c
  group FWLB
    ../../Libraries/n32g4fr_std_periph_driver/src/: misc.c n32g4fr_dma.c n32g4fr_gpio.c n32g4fr_rcc.c n32g4fr_usart.c n32g4fr_adc.c n32g4fr_can.c n32g4fr_crc.c n32g4fr_exti.c n32g4fr_flash.c n32g4fr_i2c.c n32g4fr_iwdg.c n32g4fr_pwr.c n32g4fr_qspi.c n32g4fr_rtc.c n32g4fr_sdio.c n32g4fr_spi.c n32g4fr_tim.c n32g4fr_wwdg.c
  group USER
    ../sys/: main.c n32g4fr_it.c bsp.c systick.c queue.c ringbuffer.c
  group DOC
    ../: readme.txt
  group driver
    ../driver/: uart.c dma.c spi.c gpio.c timer.c adc.c
  group dev
    ../dev/: dev_spiflash.c dev_modbus_h.c dev_led.c dev_key.c dev_board_id.c dev_fc41d_ble.c dev_fc41d_mqtt.c dev_fc41d_nova.c dev_fc41d_wifi.c dev_fc41d_common.c dev_fc41d_http.c dev_fc41d_aliyun.c dev_fc41d_nova_debug.c dev_fc41d_local_upgrade.c dev_fc41d_relay_multi_cmd_kstar.c dev_fc41d_http_mqtt_info.c dev_dbg.c dev_fc41d_socket.c
  group app
    ../app/: sys_info.c peri_process.c collector.c fc41d.c subdev.c kstar_reg_judge.c nova_dev_upgrade.c pcs_op.c pcs_op_kstar.c pcs_op_megarevo.c pcs_op_nova.c pcs_op_suro.c
    ../algo/: aes1.c
  group proto
    ../proto/: proto_nova_uniform.c
  group algo
    ../algo/: bignum.c md5.c rsa2048.c aes2.c base64.c miniz.c
