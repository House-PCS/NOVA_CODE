# Keil uVision project Project.uvprojx, settings and files
target N32G4FR (6130001::V6.13.1::.\ARMCLANG)
  device: N32G4FRKEQ7 Nationstech
  pack: Nationstech.N32G4FR_DFP.1.0.4
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: collector +hex
  AfterMake: fromelf --bin --output=.\bin\collector_boot.bin .\Objects\collector.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: N32G4FR, USE_STDPERIPH_DRIVER
  c include: ..\sys;..\..\Libraries\CMSIS\core;..\..\Libraries\CMSIS\device;..\..\Libraries\n32g4fr_std_periph_driver\inc;..\driver;..\dev;..\app;..\boot
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  scatter file: .\collector.sct
  group STARTUP
    ../../Libraries/CMSIS/device/startup/: startup_n32g4fr.s
  group CMSIS
    ../../Libraries/CMSIS/device/: system_n32g4fr.c
  group FWLB
    ../../Libraries/n32g4fr_std_periph_driver/src/: misc.c n32g4fr_dma.c n32g4fr_gpio.c n32g4fr_rcc.c n32g4fr_usart.c n32g4fr_adc.c n32g4fr_can.c n32g4fr_crc.c n32g4fr_exti.c n32g4fr_flash.c n32g4fr_i2c.c n32g4fr_iwdg.c n32g4fr_pwr.c n32g4fr_qspi.c n32g4fr_rtc.c n32g4fr_sdio.c n32g4fr_spi.c n32g4fr_tim.c n32g4fr_wwdg.c
  group USER
    ../sys/: main.c n32g4fr_it.c bsp.c systick.c queue.c
  group DOC
    ../: readme.txt
  group driver
    ../driver/: uart.c dma.c spi.c gpio.c timer.c flash.c
  group dev
    ../dev/: dev_spiflash.c dev_led.c dev_key.c dev_rs485.c
  group app
    ../app/: peri_process.c proto_uniform.c para_process.c
  group boot
    ../boot/: boot.c
