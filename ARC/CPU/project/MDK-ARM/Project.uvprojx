# Keil uVision project Project.uvprojx, settings and files
target N32G4FR (6160000::V6.16::ARMCLANG)
  device: N32G4FRKEQ7 Nationstech
  pack: Nationstech.N32G4FR_DFP.1.0.4
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ArcDetect +hex
  AfterMake: fromelf --bin --output=.\bin\ArcDetect.bin .\Objects\ArcDetect.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: N32G4FR, USE_STDPERIPH_DRIVER, ARM_MATH_CM4,__FPU_PRESENT
  c include: ..\sys;..\..\Libraries\CMSIS\core;..\..\Libraries\CMSIS\device;..\..\Libraries\n32g4fr_std_periph_driver\inc;..\driver;..\dev;..\app;..\proto;..\lib;..\dsplib\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../../Libraries/CMSIS/device/startup/: startup_n32g4fr.s
  group CMSIS
    ../../Libraries/CMSIS/device/: system_n32g4fr.c
  group FWLB
    ../../Libraries/n32g4fr_std_periph_driver/src/: misc.c n32g4fr_dma.c n32g4fr_gpio.c n32g4fr_rcc.c n32g4fr_usart.c n32g4fr_adc.c n32g4fr_can.c n32g4fr_crc.c n32g4fr_exti.c n32g4fr_flash.c n32g4fr_i2c.c n32g4fr_iwdg.c n32g4fr_pwr.c n32g4fr_qspi.c n32g4fr_rtc.c n32g4fr_sdio.c n32g4fr_spi.c n32g4fr_tim.c n32g4fr_wwdg.c
  group USER
    ../sys/: main.c n32g4fr_it.c bsp.c systick.c queue.c
  group DOC
    ../: readme.txt
  group driver
    ../driver/: uart.c dma.c spi.c gpio.c timer.c adc.c flash.c
    ../dev/: dev_modbus_s.c
  group dev
    ../dev/: dev_cur_detect.c dev_led.c dev_ht7017.c dev_mco.c dev_chan_sw.c dev_spiflash.c
  group app
    ../app/: arc_detect_info.c arc_detect_process.c arc_detect_threshold.c res_detect_process.c modbus_analysis.c alarm.c proto_uniform.c
  group dsplib
    ../lib/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 5.5.0
