# Keil uVision project CortexM0.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: CortexM0 +hex
  AfterMake: fromelf -cvf .\objects\CortexM0.axf --bin -o CortexM0.bin
  AfterMake: ..\Out\BinToCoe.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Src\Core;..\Src\System\inc;..\Src\Peripheral\inc;..\Src\RTOS\inc;..\Src\UserCode\Inc
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x4000 size 0x4000
  group StartUp
    ../Src/StartUp/: startup_CMSDK_CM0.s
  group System
    ../Src/System/src/: system_CMSDK_CM0.c
  group Peripheral
    ../Src/Peripheral/src/: Gpio.c Timer.c Uart.c BmsCache.c EthUdp.c dev_phy.c mdio.c DdrCache.c Spi.c
  group UserCode
    ../Src/UserCode/: main.c
software components: CMSIS:CORE 5.3.0
