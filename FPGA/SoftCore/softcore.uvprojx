# Keil uVision project softcore.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: Roca2-16KH_Fpga_Softcore +hex
  AfterMake: fromelf.exe --bin -o .\output\@L.bin "!L"
  AfterMake: Keil5_disp_size_bar_v0.3.exe
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: CORTEX_M0
  c include: .\cmsis\CMSIS\Include;.\cmsis\Device\ARM\CMSDK_CM0\Include;.\common\retarget;..\ram_bist_test;.\device;.\driver;.\sys;.\middleware;.\app
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x4000 size 0x4000
  group app
    ./app/: modbus_analysis.c private_analysis.c comm_analysis.c firmware_upgrate.c ut_test_mode.c ddr_process.c fault_record_process.c
  group sys
    ./cmsis/Device/ARM/CMSDK_CM0/Source/: system_CMSDK_CM0.c
    ./sys/: main.c systick.c crc.c queue.c
  group middleware
    ./middleware/: mid_comservice.c
  group driver
    ./driver/: uart.c fpga_com.c mdio.c spi.c
  group device
    ./device/: dev_led.c dev_phy.c dev_spiflash.c dev_ddr.c
  group Startup
    ./cmsis/Device/ARM/CMSDK_CM0/Source/ARM/: startup_CMSDK_CM0.s
software components: CMSIS:CORE 5.3.0
