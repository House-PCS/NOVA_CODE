# Keil uVision project Project.uvprojx, settings and files
target GD32F4XX (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.4
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: IntegratedMonitor +hex
  AfterMake: fromelf --bin --output=.\bin\IntegratedMonitor.bin .\output\IntegratedMonitor.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F470
  c misc: --C99 --diag_error=223,940 --diag_suppress=1,177
  c include: ..\..\Libraries\CMSIS\GD\GD32F4xx\Include;..\..\Utilities;..\..\Libraries\CMSIS;..\..\Template;..\..\Libraries\CMSIS\GD\GD32F4xx\Source\ARM;..\..\Libraries\GD32F4xx_standard_peripheral\Include;..\sys;..\driver;..\dev;..\emWin\GUI\Include;..\common;..\menu;..\app;..\boot
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\output\Project.sct
  group Application
    ../sys/: gd32f4xx_it.c main.c systick.c bsp.c queue.c lcd_draw.c public_proto.c
  group CMSIS
    ../sys/: system_gd32f4xx.c
  group Peripherals
    ../../Libraries/GD32F4xx_standard_peripheral/Source/: gd32f4xx_rtc.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_gpio.c gd32f4xx_dma.c gd32f4xx_exti.c gd32f4xx_rcu.c gd32f4xx_trng.c gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Startup
    ../../Libraries/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group driver
    ../driver/: adc.c dma.c exmc.c exti.c flash.c gpio.c i2c.c sim_i2c.c spi.c timer.c uart.c
  group dev
    ../dev/: dev_lcd.c dev_spiflash.c dev_modbus.c dev_key.c dev_led.c dev_it7c4337.c dev_modbus_rtu.c dev_atmos_sk68xx.c dev_mbi502x_led.c dev_tca9555.c
  group emwin_conf
    ../emWin/Config/: GUIConf.c GUIDRV_Template.c LCDConf.c GUI_X.c
  group emwin_lib
    ../emWin/GUI/Lib/ARM/: GUI_CM4F_L.lib
  group common
    ../common/: modbus_crc.c
  group app
    ../app/: firmware_upgrate.c slave_bms.c slvae_pcs.c slave_collect.c atmos_led.c timed_polling.c sys_info_storage.c miniz.c md5.c key_backlight_led.c
  group truetype
    ../menu/font/truetype/: autofit.c bdf.c cff.c ftbase.c ftbbox.c ftbdf.c ftbitmap.c ftbzip2.c ftcache.c ftcid.c ftdebug.c ftfstype.c ftgasp.c ftglyph.c ftgxval.c ftgzip.c ftinit.c ftlcdfil.c ftlzw.c ftmm.c ftotval.c ftpatent.c ftpfr.c ftstroke.c ftsynth.c ftsystem.c fttype1.c ftwinfnt.c ftxf86.c GUI_BDF.c GUI_FT.c GUI_TTF.c gxvalid.c otvalid.c pcf.c pfr.c psaux.c pshinter.c psnames.c raster.c sfnt.c smooth.c truetype.c type1.c type1cid.c type42.c winfnt.c
    ../menu/font/: ITC Avant Garde Std Md16.c
  group boot
    ../boot/: boot.c
