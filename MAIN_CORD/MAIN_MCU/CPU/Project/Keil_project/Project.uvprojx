# Keil uVision project Project.uvprojx, settings and files
target GD32F4XX (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.4
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: IntegratedMonitor +hex
  AfterMake: fromelf --bin --output=.\bin\IntegratedMonitor.bin .\output\IntegratedMonitor.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F470
  c misc: --C99 --diag_error=223,940 --diag_suppress=1,177
  c include: ..\..\Libraries\CMSIS\GD\GD32F4xx\Include;..\..\Utilities;..\..\Libraries\CMSIS;..\..\Template;..\..\Libraries\CMSIS\GD\GD32F4xx\Source\ARM;..\..\Libraries\GD32F4xx_standard_peripheral\Include;..\sys;..\driver;..\dev;..\emWin\GUI\Include;..\common;..\menu;..\app;..\cm_back;..\lwip-2.1.2\src\core;..\lwip-2.1.2\src\api;..\lwip-2.1.2\port\GD32F4xx\Basic;..\lwip-2.1.2\src\include\lwip;..\lwip-2.1.2\src\include;..\lwip-2.1.2\port;..\lwip-2.1.2\port\GD32F4xx\arch;..\lwip-2.1.2\port\GD32F4xx;..\lwip-2.1.2\src\netif;..\test_demo
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0xb0000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Project.sct
  group Application
    ../sys/: gd32f4xx_it.c main.c systick.c bsp.c queue.c lcd_draw.c public_proto.c debug.c shell.c gd32f4xx_enet_eval.c netconf.c hello_gigadevice.c
  group CMSIS
    ../sys/: system_gd32f4xx.c
  group Peripherals
    ../../Libraries/GD32F4xx_standard_peripheral/Source/: gd32f4xx_rtc.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_gpio.c gd32f4xx_dma.c gd32f4xx_exti.c gd32f4xx_rcu.c gd32f4xx_trng.c gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Startup
    ../../Libraries/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group driver
    ../driver/: adc.c dma.c exmc.c exti.c flash.c gpio.c i2c.c sim_i2c.c spi.c timer.c uart.c can.c
  group dev
    ../dev/: dev_lcd.c dev_spiflash.c dev_modbus.c dev_key.c dev_led.c dev_it7c4337.c dev_modbus_rtu.c dev_mbi502x_led.c dev_udp_comm.c rtl8309n_asicdrv.c
  group emwin_conf
    ../emWin/Config/: GUIConf.c GUIDRV_Template.c LCDConf.c GUI_X.c
  group emwin_lib
    ../emWin/GUI/Lib/ARM/: GUI_CM4F_L.lib
  group common
    ../common/: modbus_crc.c
  group menu
    ../menu/: em_menu.c em_startup.c em_main.c em_list_opera_info.c em_list.c em_popup.c em_popup_error.c em_list_equip_opera_info.c em_list_volt_curr_power_info.c em_list_grid_info.c em_list_generator_input.c em_list_back_up_load_Info.c em_list_normal_load_info.c em_list_battery_info.c em_list_battery_pack_info.c em_list_inverter_info.c em_list_temperature_info.c em_list_status_info.c em_list_system_settings_info.c em_list_pv_input_info.c em_main_3d_nav.c em_list_factory_restore.c em_list_settings_info.c em_list_work_mode_info.c em_list_advanced_settings.c em_list_advanced_system.c em_list_advanced_battery.c em_list_grid_stand.c em_list_grid_stand_flag.c em_list_grid_stand_confirm.c em_list_extened_meter_brand.c em_list_reconn_gird_time.c em_list_run_setting.c em_list_set_time_info.c em_list_set_time_save_info.c em_list_set_data_info.c em_list_pop_confirm_info.c em_list_enter_password.c em_list_dev_base_info.c em_3d_homepage.c em_list_arm_dsp_version.c em_list_batt_pack_ver_info.c em_list_fault_record_info.c em_electricity_info.c em_list_advanced_battery_dod.c em_list_advan_bat_discha_cha_curr.c em_list_advan_bat_discha_cha_power.c em_list_advan_bat_discha_cha_volt.c em_list_advanced_battery_waken_time.c em_list_opt_parm_info.c em_list_advanced_system_pv_input_mode.c em_list_opt_parm_ongrid_power.c em_list_opt_parm_react_mode.c em_list_opt_parm_network_limit_enbale.c em_list_opt_parm_network_limit_power.c em_list_opt_parm_grid_ovp_point.c em_list_opt_parm_inverter_uvp_point.c em_list_opt_parm_ofp_point.c em_list_opt_parm_ufp_point.c em_list_opt_parm_ovd_point.c em_list_opt_parm_uvd_point.c em_list_opt_parm_ofd_point.c em_list_opt_parm_ufd_point.c em_list_opt_parm_reactive_respon_tim.c em_list_opt_parm_grid_drop_switch.c em_list_advanced_language.c em_list_advanced_language_type.c em_list_advanced_lcd_backlight.c em_list_advanced_lcd_backlight_time.c em_list_advanced_restore_factory.c em_list_advanced_set_password.c em_list_advanced_del_history_fault.c em_list_advanced_del_history_fault_popup.c em_list_advanced_communication.c em_list_advanced_communication_485adress.c em_list_advanced_communication_baud_rate.c em_list_advanced_restore_factory_popup.c em_debug_window.c em_upgrade.c em_upgrading.c em_popup_peak_shifting_time_error.c em_list_dbg_react_power_ctrl_mode.c em_list_advanced_system_generator_power.c em_popup_shut_down_window.c
  group app
    ../app/: firmware_upgrate.c slave_bms.c slvae_pcs.c slave_collect.c system_ctrl.c storage_cap.c timed_polling.c sys_info_storage.c miniz.c md5.c error_proc.c tools_program.c program_sn.c slave_meter.c rtk_api.c slave_coprocessor.c
  group truetype
    ../menu/font/truetype/: autofit.c bdf.c cff.c ftbase.c ftbbox.c ftbdf.c ftbitmap.c ftbzip2.c ftcache.c ftcid.c ftdebug.c ftfstype.c ftgasp.c ftglyph.c ftgxval.c ftgzip.c ftinit.c ftlcdfil.c ftlzw.c ftmm.c ftotval.c ftpatent.c ftpfr.c ftstroke.c ftsynth.c ftsystem.c fttype1.c ftwinfnt.c ftxf86.c GUI_BDF.c GUI_FT.c GUI_TTF.c gxvalid.c otvalid.c pcf.c pfr.c psaux.c pshinter.c psnames.c raster.c sfnt.c smooth.c truetype.c type1.c type1cid.c type42.c winfnt.c
    ../menu/font/: ITC Avant Garde Std Md16.c
  group cm_back
    ../cm_back/: cm_backtrace.c cmb_fault.S
  group lwip
    ../lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip_port
    ../lwip-2.1.2/port/GD32F4xx/Basic/: ethernetif.c
    ../lwip-2.1.2/src/netif/: ethernet.c
