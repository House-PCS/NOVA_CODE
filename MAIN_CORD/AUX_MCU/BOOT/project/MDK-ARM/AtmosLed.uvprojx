# Keil uVision project AtmosLed.uvprojx, settings and files
target N32G4FR (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G4FRKEQ7 Nationstech
  pack: Nationstech.N32G4FR_DFP.1.0.4
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AtmosLedboot +hex
  AfterMake: fromelf --bin --output=.\bin\AtmosLedboot.bin .\Objects\AtmosLedboot.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G4FR, USE_STDPERIPH_DRIVER
  c misc: --c99 --diag_suppress=177,550,1295
  c include: ..\..\Libraries\CMSIS\device\startup;..\..\Libraries\CMSIS\core;..\..\Libraries\CMSIS\device;..\..\Libraries\n32g4fr_std_periph_driver\inc;..\sys;..\app;..\dev;..\driver;..\boot
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../../Libraries/CMSIS/device/startup/: startup_n32g4fr.s
  group CMSIS
    ../../Libraries/CMSIS/device/: system_n32g4fr.c
  group FWLB
    ../../Libraries/n32g4fr_std_periph_driver/src/: misc.c n32g4fr_adc.c n32g4fr_bkp.c n32g4fr_can.c n32g4fr_crc.c n32g4fr_dac.c n32g4fr_dbg.c n32g4fr_dma.c n32g4fr_dvp.c n32g4fr_exti.c n32g4fr_flash.c n32g4fr_gpio.c n32g4fr_i2c.c n32g4fr_iwdg.c n32g4fr_pwr.c n32g4fr_qspi.c n32g4fr_rcc.c n32g4fr_rtc.c n32g4fr_sdio.c n32g4fr_spi.c n32g4fr_tim.c n32g4fr_tsc.c n32g4fr_usart.c n32g4fr_wwdg.c
  group USER
    ../sys/: main.c bsp.c queue.c systick.c n32g4fr_it.c public_proto.c
  group DOC
    ../: readme.txt
  group driver
    ../driver/: adc.c dma.c gpio.c spi.c timer.c uart.c flash.c
  group dev
    ../dev/: dev_modbus_h.c dev_atmos_sk68xx.c dev_modbus_rtu.c dev_atmos_sy_adbic.c
  group app
    ../app/: timed_polling.c slave_ledctl.c atmos_led.c key_backlight_led.c atmos_side_led.c firmware_upgrate.c
  group boot
    ../boot/: boot.c
