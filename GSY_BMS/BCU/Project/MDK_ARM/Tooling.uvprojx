# Keil uVision project Tooling.uvprojx, settings and files
target GD32F470ZE (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CMU_A3 +hex
  AfterMake: fromelf.exe --bin -o .\Objects\@L.bin "!L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F470
  c include: ..\..\Libraries\GD32F4xx\GD32F4xx_standard_peripheral\Include;..\..\Libraries\GD32F4xx\CMSIS;..\..\Libraries\GD32F4xx\CMSIS\GD\GD32F4xx\Include;..\..\Libraries\GD32F4xx\CMSIS\GD\GD32F4xx\Source\ARM;..\sys;..\driver;..\device;..\lwip;..\lwip\src\include\lwip;..\lwip\src\netif;..\lwip\src\include;..\lwip\src\core\ipv4;..\lwip\port\GD32F4xx\arch;..\app;..\middleware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../app/: bcu_sox.c alarm.c high_volt_detect.c current_detect.c temp_detect.c ins_res_detect.c bms_data_manage.c bmu_ctl.c can_tx_rx_process.c sys_run.c timer_polling.c data_storage_manage.c current_limit.c can_proto_addr_mask.c can_proto_bmu.c can_proto_pcs.c can_proto_upgrate.c modbus_slave_process.c modbus_upstream_analysis.c event_log.c can_proto_debug.c can_proto_factory_test.c function_test.c rs485_test.c
  group sys
    ../sys/: main.c systick.c mcu_bsp.c queue.c gd32f4xx_it.c ntc_convert.c filter_calc.c crc.c
  group middleware
    ../middleware/: peri_ctl_stat_api.c
  group device
    ../device/: dev_24c32.c dev_spiflash.c dev_sd2506.c dev_volt_detect.c dev_ioctl.c dev_sgm58031.c dev_ht7017.c dev_can_comm.c dev_uart_comm.c dev_led.c
  group driver
    ../driver/: adc.c can.c dma.c exti.c flash.c fwdgt.c gpio.c i2c.c rtc.c sim_i2c.c spi.c timer.c uart.c
  group CMSIS
    ../../Libraries/GD32F4xx/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
    ../../Libraries/GD32F4xx/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Library
    ../../Libraries/GD32F4xx/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
