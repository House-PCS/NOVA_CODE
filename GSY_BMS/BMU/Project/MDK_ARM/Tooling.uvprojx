# Keil uVision project Tooling.uvprojx, settings and files
target GD32F303RB (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303RB GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CMC_32T26 +hex
  AfterMake: fromelf.exe --bin --output .\bin\bmu32.bin .\Objects\CMC_32T26.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F30X_HD
  c misc: --C99 --diag_error=223,940 --diag_suppress=1,177
  c include: ..\app;..\device;..\driver;..\middleware;..\sys;..\..\Library\CMSIS\GD\GD32F30x\Include;..\..\Library\CMSIS;..\..\Library\Include;..\..\Library\CMSIS\GD\GD32F30x\Source\IAR;..\adbms6830_lib
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group app
    ../app/: function_test.c can_tx_rx_process.c can_proto_addr.c can_proto_bms.c can_proto_debug.c can_proto_upgrate.c can_proto_test.c can_proto_factory_functest.c afe_ctl.c bmu_data_manage.c bmu_data_storage_manage.c
  group sys
    ../sys/: gd32f30x_it.c systick.c main.c queue.c ntc_convert.c crc.c mcu_bsp.c
  group device
    ../device/: dev_can_comm.c dev_ioctl.c dev_spiflash.c dev_adbms6830.c dev_pwm_detect_cfg.c dev_led.c
  group driver
    ../driver/: dma.c exti.c fwdgt.c gpio.c i2c.c rtc.c sim_i2c.c spi.c uart.c adc.c can.c flash.c timer.c
  group CMSIS
    ../../Library/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ../../Library/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group Library
    ../../Library/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group adbms6830_lib
    ../adbms6830_lib/: adBms6830GenericType.c adBms6830ParseCreate.c mcuWrapper.c
