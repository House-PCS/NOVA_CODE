# Keil uVision project GD32F303.uvprojx, settings and files
target GD32F303 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303VE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F303 +hex
  AfterMake: fromelf.exe --bin -o .\GD303_OUT\@L.bin "!L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=2
  c define: GD32F30X_HD
  c misc: --C99 --diag_error=223,940 --diag_suppress=1,177
  c include: ..\Libraries\GD32F30x\GD32F30x_standard_peripheral\Include;..\Libraries\GD32F30x\CMSIS;..\Libraries\GD32F30x\CMSIS\GD\GD32F30x\Include;.\driver;.\sys;.\middleware;.\device;.\app;.\protocol_stack\can;.\cm_back;.\adbms6830_lib
  library: MicroLIB
  memory RVCT4: ROM 0x8012000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ./app/: sys_info.c modbus_analysis.c led_process.c cell_process.c commonpack_analysis.c current_control.c bms_protocol.c tooling.c power_limit.c can_main_card.c can_tx_rx_process.c
    ./middleware/: sq52201_control.c
  group sys
    ./sys/: debug.c gd32f30x_it.c main.c queue.c systick.c bsp.c
  group middleware
    ./middleware/: mid_shell.c afe_control.c sensor_control.c sox.c fault_analysis.c filter_calc.c fwdgt_ctl.c
  group device
    ./device/: dev_led.c dev_adbms6830.c dev_key.c dev_ntc.c dev_spiflash.c dev_at24cxx.c dev_system_power.c dev_mos.c dev_communication.c dev_sq52201.c dev_can_comm.c
  group driver
    ./driver/: adc.c can.c dma.c exti.c gpio.c i2c.c rtc.c spi.c sim_i2c.c timer.c uart.c fwdgt.c flash.c
  group CMSIS
    ../Libraries/GD32F30x/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ../Libraries/GD32F30x/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s startup_gd32f30x_cl.s
  group SPL_GD32F30x
    ../Libraries/GD32F30x/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group cm_back
    ./cm_back/: cm_backtrace.c cmb_fault.S
  group adbms6830_lib
    ./adbms6830_lib/: adBms6830GenericType.c adBms6830ParseCreate.c mcuWrapper.c
